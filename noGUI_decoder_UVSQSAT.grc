options:
  parameters:
    author: Enzo BECAMEL F4IAI
    description: Decoder for UVSQ-SAT
    generate_options: no_gui
    id: nogui_decoder_UVSQSAT_IQ
    output_language: python
    run_options: run
    title: Decoder from IQ file for UVSQ-SAT
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '39000'
  states: {}
- name: start_time_value
  id: variable_config
  parameters:
    config_file: /path/to/start_time.ini
    option: key
    section: main
    type: string
    value: '"time"'
    writeback: None
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/rx.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    iq: 'True'
    norad: '47438'
    samp_rate: samp_rate
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: '0.000000'
    longitude: '0.000000'
    noradID: '47438'
    source: your_call
    tstamp: start_time_value
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_telemetry_parser_0
  id: satellites_telemetry_parser
  parameters:
    definition: ax25
    file: grc_out.txt
    output: file
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', satellites_satellite_decoder_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print_pdu]
- [satellites_satellite_decoder_0, out, satellites_submit_0, in]
- [satellites_satellite_decoder_0, out, satellites_telemetry_parser_0, in]

metadata:
  file_format: 1
